<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\mb9af31xk_example_178172004.ewp</path>
  </project>
  <batchBuild/>
</workspace>


