# IAR project mb9af31xk_example_178172004.ewp, settings and files
configuration MB9A312_Release (ARM, debug)
  General.OGChipSelectEditMenu: MB9A312K  Spansion MB9A312K
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\common; ..\..\example\source; ..\..\example\source\config; ..\..\library; ..\..\library\highlevel; ..\..\library\middleware; ..\..\library\lowlevel; ..\source\sk-fm3-48pmc-usbstick; ..\source\config\usb; ..\..\library\lowlevel\usb; ..\..\library\middleware\usb\host; ..\..\library\middleware\usb\device
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: mb9af31xk_example_178172004.srec
  ILINK.IlinkOutputFile: mb9af31xk_example_178172004.out
  ILINK.IlinkIcfFile: config\mb9a312_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MB9A312_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ILINK.IlinkIcfFile: config\mb9a312_ram.icf
configuration MB9A311_Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9A311K  Spansion MB9A311K
  ILINK.IlinkIcfFile: config\mb9a311_rom.icf
configuration MB9A311_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ILINK.IlinkIcfFile: config\mb9a311_ram.icf
  group (top)
    ../../: Readme.txt
  group common
    ../../common/: system_mb9a310k.c
  group config
    ../source/config/: iomux.c
  group config/usb
    ../source/config/usb/: UsbConfig.c UsbConfig.c UsbConfig.c UsbConfig.c usbdescriptors.h usbdescriptors.h usbdescriptors.h usbdescriptors.h usbdevicehw.h usbdevicehw.h usbdevicehw.h usbdevicehw.h usbhosthw.h usbhosthw.h usbhosthw.h usbhosthw.h usbconfig.h usbconfig.h usbconfig.h usbconfig.h
  group source
    ../source/: main.c
    ./: startup_mb9a310k.s
  group source/sk-fm3-48pmc-usbstick
    ../source/sk-fm3-48pmc-usbstick/: board.c board.c board.c board.c board.h board.h board.h board.h boardconfig.h boardconfig.h boardconfig.h boardconfig.h boardsystick.c boardsystick.c boardsystick.c boardsystick.c boardsystick.h boardsystick.h boardsystick.h boardsystick.h button.c button.c button.c button.c button.h button.h button.h button.h led.h led.h led.h led.h ledpwm.c ledpwm.c ledpwm.c ledpwm.c ledpwm.h ledpwm.h ledpwm.h ledpwm.h sensoradc.c sensoradc.c sensoradc.c sensoradc.c sensoradc.h sensoradc.h sensoradc.h sensoradc.h uart.c uart.c uart.c uart.c uart.h uart.h uart.h uart.h
  group library/lowlevel/usb
    ../../library/lowlevel/usb/: usb.c usb.c usb.c usb.c usb.h usb.h usb.h usb.h usbdevice.c usbdevice.c usbdevice.c usbdevice.c usbdevice.h usbdevice.h usbdevice.h usbdevice.h usbethernetclock.c usbethernetclock.c usbethernetclock.c usbethernetclock.c usbethernetclock.h usbethernetclock.h usbethernetclock.h usbethernetclock.h usbethernetclocklegacy.h usbethernetclocklegacy.h usbethernetclocklegacy.h usbethernetclocklegacy.h usbhost.c usbhost.c usbhost.c usbhost.c usbhost.h usbhost.h usbhost.h usbhost.h usblegacy.h usblegacy.h usblegacy.h usblegacy.h
  group library/middleware/usb/host
    ../../library/middleware/usb/host/: UsbHostClassDriverTable.h UsbHostClassDriverTable.h UsbHostClassDriverTable.h UsbHostClassDriverTable.h UsbHostClassSupervisor.c UsbHostClassSupervisor.c UsbHostClassSupervisor.c UsbHostClassSupervisor.c usbhostclasssupervisor.h usbhostclasssupervisor.h usbhostclasssupervisor.h usbhostclasssupervisor.h UsbHostHidCom.c UsbHostHidCom.c UsbHostHidCom.c UsbHostHidCom.c usbhosthidcom.h usbhosthidcom.h usbhosthidcom.h usbhosthidcom.h UsbHostHidKeyboard.c UsbHostHidKeyboard.c UsbHostHidKeyboard.c UsbHostHidKeyboard.c UsbHostHidKeyboard.h UsbHostHidKeyboard.h UsbHostHidKeyboard.h UsbHostHidKeyboard.h UsbHostHidMouse.c UsbHostHidMouse.c UsbHostHidMouse.c UsbHostHidMouse.c UsbHostHidMouse.h UsbHostHidMouse.h UsbHostHidMouse.h UsbHostHidMouse.h UsbHostMassStorage.c UsbHostMassStorage.c UsbHostMassStorage.c UsbHostMassStorage.c UsbHostMassStorage.h UsbHostMassStorage.h UsbHostMassStorage.h UsbHostMassStorage.h UsbHostNdis.c UsbHostNdis.c UsbHostNdis.c UsbHostNdis.c UsbHostNdis.h UsbHostNdis.h UsbHostNdis.h UsbHostNdis.h UsbHostPrinter.c UsbHostPrinter.c UsbHostPrinter.c UsbHostPrinter.c UsbHostPrinter.h UsbHostPrinter.h UsbHostPrinter.h UsbHostPrinter.h
  group library/middleware/usb/device
    ../../library/middleware/usb/device/: UsbDeviceCdcCom.c UsbDeviceCdcCom.c UsbDeviceCdcCom.c UsbDeviceCdcCom.c UsbDeviceCdcCom.h UsbDeviceCdcCom.h UsbDeviceCdcCom.h UsbDeviceCdcCom.h UsbDeviceCmsisDap.c UsbDeviceCmsisDap.c UsbDeviceCmsisDap.c UsbDeviceCmsisDap.c UsbDeviceCmsisDap.h UsbDeviceCmsisDap.h UsbDeviceCmsisDap.h UsbDeviceCmsisDap.h UsbDeviceHidCom.c UsbDeviceHidCom.c UsbDeviceHidCom.c UsbDeviceHidCom.c UsbDeviceHidCom.h UsbDeviceHidCom.h UsbDeviceHidCom.h UsbDeviceHidCom.h UsbDeviceHidJoystick.c UsbDeviceHidJoystick.c UsbDeviceHidJoystick.c UsbDeviceHidJoystick.c UsbDeviceHidJoystick.h UsbDeviceHidJoystick.h UsbDeviceHidJoystick.h UsbDeviceHidJoystick.h UsbDeviceHidKeyboard.c UsbDeviceHidKeyboard.c UsbDeviceHidKeyboard.c UsbDeviceHidKeyboard.c UsbDeviceHidKeyboard.h UsbDeviceHidKeyboard.h UsbDeviceHidKeyboard.h UsbDeviceHidKeyboard.h UsbDeviceHidMouse.c UsbDeviceHidMouse.c UsbDeviceHidMouse.c UsbDeviceHidMouse.c UsbDeviceHidMouse.h UsbDeviceHidMouse.h UsbDeviceHidMouse.h UsbDeviceHidMouse.h UsbDeviceLibUsb.c UsbDeviceLibUsb.c UsbDeviceLibUsb.c UsbDeviceLibUsb.c UsbDeviceLibUsb.h UsbDeviceLibUsb.h UsbDeviceLibUsb.h UsbDeviceLibUsb.h UsbDeviceMassStorage.c UsbDeviceMassStorage.c UsbDeviceMassStorage.c UsbDeviceMassStorage.c UsbDeviceMassStorage.h UsbDeviceMassStorage.h UsbDeviceMassStorage.h UsbDeviceMassStorage.h UsbDevicePrinter.c UsbDevicePrinter.c UsbDevicePrinter.c UsbDevicePrinter.c UsbDevicePrinter.h UsbDevicePrinter.h UsbDevicePrinter.h UsbDevicePrinter.h
