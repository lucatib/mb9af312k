# Keil uVision project mb9af31xk_example_178172004.uvprojx, settings and files
target MB9A312_Debug (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.1.0
  cpu: IRAM1(0x1FFFE000,0x2000) IRAM2(0x20000000,0x2000) IROM(0x0,0x20000) IROM2(0x200C0000,0x8000) CPUTYPE"(Cortex-M3") CLOCK(-1) ELITTLE
  output: mb9af31xk_example_178172004 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\..\common;..\..\example\source;..\..\example\source\config;..\..\library;..\..\library\lowlevel;..\..\library\middleware;..\..\library\highlevel;..\source\sk-fm3-48pmc-usbstick;..\source\config\usb;..\..\library\lowlevel\usb;..\..\library\middleware\usb\host;..\..\library\middleware\usb\device
  memory RVCT4: ROM 0x1fffe000 size 0x1000
  memory RVCT5: ROM 0x200c0000 size 0x8000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x2000
  group common
    ../../common/: system_mb9a310k.c system_fm3.c
  group source
    ../source/: main.c pdl_user.h
    ../../: Readme.txt
    ./: startup_mb9a310k.s startup_fm.s
  group config
    ../source/config/: iomux.c
  group source/sk-fm3-48pmc-usbstick
    ../source/sk-fm3-48pmc-usbstick/: board.c board.h boardconfig.h boardsystick.c boardsystick.h button.c button.h led.h ledpwm.c ledpwm.h sensoradc.c sensoradc.h uart.c uart.h
  group config/usb
    ../source/config/usb/: UsbConfig.c usbdescriptors.h usbdevicehw.h usbhosthw.h usbconfig.h
  group library/lowlevel
    ../../library/lowlevel/usb/: usb.c usb.h usbdevice.c usbdevice.h usbethernetclock.c usbethernetclock.h usbethernetclocklegacy.h usbhost.c usbhost.h usblegacy.h
  group library/middleware
    ../../library/middleware/usb/host/: UsbHostClassDriverTable.h UsbHostClassSupervisor.c usbhostclasssupervisor.h UsbHostHidCom.c usbhosthidcom.h UsbHostHidKeyboard.c UsbHostHidKeyboard.h UsbHostHidMouse.c UsbHostHidMouse.h UsbHostMassStorage.c UsbHostMassStorage.h UsbHostNdis.c UsbHostNdis.h UsbHostPrinter.c UsbHostPrinter.h
    ../../library/middleware/usb/device/: UsbDeviceCdcCom.c UsbDeviceCdcCom.h UsbDeviceCmsisDap.c UsbDeviceCmsisDap.h UsbDeviceHidCom.c UsbDeviceHidCom.h UsbDeviceHidJoystick.c UsbDeviceHidJoystick.h UsbDeviceHidKeyboard.c UsbDeviceHidKeyboard.h UsbDeviceHidMouse.c UsbDeviceHidMouse.h UsbDeviceLibUsb.c UsbDeviceLibUsb.h UsbDeviceMassStorage.c UsbDeviceMassStorage.h UsbDevicePrinter.c UsbDevicePrinter.h
  group driver
    ../../driver/mfs/: mfs.c
    ../../driver/: interrupts_fm3.c pdl.c
target MB9A312_Release (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MB9AF312K Cypress
  pack: Keil.FM3Basic_DFP.1.0.1
  cpu: IRAM(0x20000000,0x2000) IRAM2(0x1FFFE000,0x2000) IROM(0x00000000,0x20000) IROM2(0x200C0000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mb9af31xk_example_178172004 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: __CORE_FM3__
  c include: ..\..\common;..\..\example\source;..\..\example\source\config;..\..\library;..\..\library\lowlevel;..\..\library\middleware;..\..\library\highlevel;..\source\sk-fm3-48pmc-usbstick;..\source\config\usb;..\..\library\lowlevel\usb;..\..\library\middleware\usb\host;..\..\library\middleware\usb\device;..\..\driver
  asm define: __CORE_FM3__
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x200c0000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
target MB9A311_Debug (ARM-ADS)
  device: ARMCM3 ARM
  cpu: IRAM1(0x1FFFE000,0x2000) IRAM2(0x20000000,0x2000) IROM(0x0,0x10000) IROM2(0x200C0000,0x8000) CPUTYPE"(Cortex-M3") CLOCK(-1) ELITTLE
  output: mb9af31xk_example_178172004 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: as above
  memory RVCT4: ROM 0x1fffe000 size 0x1000
  memory RVCT5: ROM 0x200c0000 size 0x8000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x2000
target MB9A311_Release (ARM-ADS)
  device: ARMCM3 ARM
  cpu: as above
  output: mb9af31xk_example_178172004 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: as above
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT5: ROM 0x200c0000 size 0x8000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
software components: CMSIS:CORE 5.0.2
